# Keil uVision project STM32_FreeRTOS.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\src;..\FWLIB\inc;..\USER;.\L1_Hardware;.\L1_Hardware\L1_LED;.\L1_Hardware\L1_Bottom;.\L1_Hardware\L1_USART;.\L1_Hardware\L1_Delay;.\L1_Hardware\L1_Flash;.\L1_Hardware\L1_Timer;.\L1_Hardware\L1_EEPROM;.\L1_Hardware\L1_CMOS;.\L1_Hardware\L1_SD;.\L1_Hardware\L1_TFTLCD;.\L2_Action;.\L2_Action\L2_PushBottom;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group L1_Hardware
    ./L1_Hardware/L1_Bottom/: L1_Bottom.c
    ./L1_Hardware/L1_LED/: L1_LED.c
    ./L1_Hardware/L1_Delay/: L1_Delay.c
    ./L1_Hardware/L1_USART/: L1_USART.c
    ./L1_Hardware/L1_Flash/: L1_Flash.c
    ./L1_Hardware/L1_Timer/: L1_Timer.c
    ./L1_Hardware/L1_EEPROM/: L1_EEPROM.c
    ./L1_Hardware/L1_CMOS/: L1_CMOS.c
    ./L1_Hardware/L1_TFTLCD/: L1_TFTLCD.c
    ./L1_Hardware/L1_SD/: L1_SD.c
  group L2_Action
    ./L2_Action/L2_PushBottom/: L2_PushBottom.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
