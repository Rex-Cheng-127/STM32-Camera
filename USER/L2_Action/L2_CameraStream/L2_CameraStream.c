/**
 ******************************************************************************
 * @file           : L2_CameraStream.c
 * @brief          : Process Camera Stream
 * @author         : Rex Cheng (bloodmooon1993@gmail.com)
 * @copyright      : Copyright (c) 2023
 ******************************************************************************
 */

/****************************************************************************************************************
 * Includes
 ****************************************************************************************************************/
#include "L2_CameraStream.h"

/****************************************************************************************************************
 * Private typedef
 ****************************************************************************************************************/

/****************************************************************************************************************
 * Private define
 ****************************************************************************************************************/
#define LCD_CS_HIGH() (GPIOB->BSRR = GPIO_Pin_9)

/****************************************************************************************************************
 * Private macro
 ****************************************************************************************************************/

/****************************************************************************************************************
 * Private variables
 ****************************************************************************************************************/
volatile uint32_t g_frameCount = 0;

/****************************************************************************************************************
 * Private function prototypes
 ****************************************************************************************************************/

/****************************************************************************************************************
 * Private functions
 ****************************************************************************************************************/

extern SemaphoreHandle_t xSemVSync;
extern void LCD_SetWindow(uint16_t x0, uint16_t y0, uint16_t x1, uint16_t y1);

/* PA2 (VSYNC) 外部中斷：偵測到新影格開始時釋放二進位信號量 */
void EXTI2_IRQHandler(void)
{
  if (EXTI_GetITStatus(EXTI_Line2) != RESET)
  {
    EXTI_ClearITPendingBit(EXTI_Line2);

    BaseType_t xHigherPriorityTaskWoken = pdFALSE;
    if (xSemVSync != NULL)
    {
      xSemaphoreGiveFromISR(xSemVSync, &xHigherPriorityTaskWoken);
    }
    portYIELD_FROM_ISR(xHigherPriorityTaskWoken);
  }
}

/* 擷取一整張 QVGA (320x240) RGB565 影格並即時直傳至 ILI9341 */
void OV7670_CaptureFrameToLCD(void)
{
  /* 1. 設定全螢幕繪圖區 (320x240) 並進入 GRAM 寫入狀態 */
  LCD_SetWindow(0, 0, 319, 239);

  /* 2. 逐列採樣：共 240 列，每列 320 像素 = 640 Bytes */
  for (uint16_t row = 0; row < 240; row++)
  {
    /* 等待 HREF (PA1) 變高，附逾時保護避免鏡頭異常時卡死 */
    uint32_t timeout = 120000;
    while ((GPIOA->IDR & GPIO_Pin_1) == 0)
    {
      if (--timeout == 0)
        goto abort_frame;
    }

    /* 關鍵：整列採樣期間關閉排程與中斷，確保 PCLK 邊緣採樣不掉封包 */
    taskENTER_CRITICAL();

    for (uint16_t byteIdx = 0; byteIdx < 640; byteIdx++)
    {
      /* 等待 PCLK (PA0) 上升沿 */
      while ((GPIOA->IDR & GPIO_Pin_0) == 0)
        ;

      /* 讀取 PC0~PC7 並原子寫入 PB0~PB7 */
      uint8_t pixelByte = (uint8_t)(GPIOC->IDR & 0x00FF);
      GPIOB->BSRR = ((uint32_t)(~pixelByte & 0x00FF) << 16) | pixelByte;

      /* 產生 LCD_WR (PC10) 寫入脈衝 */
      GPIOC->BRR = GPIO_Pin_10;
      __NOP();
      GPIOC->BSRR = GPIO_Pin_10;

      /* 等待 PCLK 回到低電位 */
      while ((GPIOA->IDR & GPIO_Pin_0) != 0)
        ;
    }

    taskEXIT_CRITICAL();

    /* 等待 HREF 結束 (水平空白期間可正常執行中斷與其他排程) */
    timeout = 120000;
    while ((GPIOA->IDR & GPIO_Pin_1) != 0)
    {
      if (--timeout == 0)
        break;
    }
  }

  g_frameCount++;

abort_frame:
  LCD_CS_HIGH();
}

/****************************************************************************************************************
 * End of file
 ****************************************************************************************************************/